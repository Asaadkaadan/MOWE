# Keil uVision project MOWE_ProjectX.uvprojx, settings and files
target Module 1 (ARM-ADS)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0-dev0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Module 1 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xC,_module_1
  c include: .\AOS;.\Apps;.\HAL;.\HAL\STM32F0xx_HAL_Driver\Inc;.\HAL\CMSIS\Device\ST\STM32F0xx\Include;.\HAL\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group HAL
    ./HAL/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c
    ./HAL/: system_stm32f0xx.c startup_stm32f091.s
  group AOS
    ./AOS/: aos_pd_adc.c aos_pd_dma.c aos_pd_gpio.c aos_pd_usart.c aos_pd_tim.c aos_pd_stm32f0xx_it.c aos_md_dbase.c aos_md_fe.c aos_iac_routing.c aos_clp.c
  group Local Apps
    ./Apps/: main.c
target Module 2 (ARM-ADS)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: as above
  output: Module 2 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xC,_module_2
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Module 3 (ARM-ADS)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: as above
  output: Module 3 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xC,_module_3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Module 4 (ARM-ADS)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: as above
  output: Module 4 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xC,_module_4
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Module 5 (ARM-ADS)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: as above
  output: Module 5 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xC,_module_5
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Module 6 (ARM-ADS)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: as above
  output: Module 6 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xC,_module_6
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Module 7 (ARM-ADS)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: as above
  output: Module 7 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F091xC,_module_7
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
